File: pcb/usb_hub.kicad_pcb (KiCad board)
At the start: 2 copper layers, 70 x 50 mm, 18 parts, among them U1 CH334R

Commit message: prettified
Other:
- board text added: "jellyfih"
